## menuconfig/arch/x86/Kconfig
```kconfig
config HELLO_WORLD
	bool "hello world"

config HELLO_WORLD2
	bool "hello world 2"
```
